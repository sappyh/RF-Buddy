options:
  parameters:
    generate_options: no_gui
    id: top_block
    output_language: python
    realtime_scheduling: '1'
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: 4e6
  states: {}
- name: IEEE154RX_0
  id: IEEE154RX
  parameters: {}
  states: {}
- name: analog_pwr_squelch_xx_0
  id: analog_pwr_squelch_xx
  parameters:
    alpha: '1e-4'
    gate: 'True'
    ramp: '0'
    threshold: '-25'
    type: complex
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: /home/saptarshi/Desktop/Papers/RF-Buddy/Code/capture.pcap
    type: byte
    unbuffered: 'True'
  states: {}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {state: disabled}
- name: blocks_tag_gate_0
  id: blocks_tag_gate
  parameters:
    propagate_tags: 'False'
    type: complex
  states: {}
- name: foo_wireshark_connector_0
  id: foo_wireshark_connector
  parameters:
    debug: 'False'
    tech: '195'
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: RX2
    bw0: 5e6
    center_freq0: 2.48e9
    clock_rate: '0.0'
    dc_offs_enb0: '""'
    dev_args: '""'
    gain0: '0.5'
    iq_imbal_enb0: '""'
    norm_gain0: 'True'
    samp_rate: samp_rate
    sync: pc_clock
    type: fc32
  states: {}

connections:
- [IEEE154RX_0, rxout, blocks_message_debug_0, print]
- [IEEE154RX_0, rxout, foo_wireshark_connector_0, in]
- [analog_pwr_squelch_xx_0, '0', blocks_tag_gate_0, '0']
- [blocks_tag_gate_0, '0', IEEE154RX_0, '0']
- [foo_wireshark_connector_0, '0', blocks_file_sink_0, '0']
- [uhd_usrp_source_0, '0', analog_pwr_squelch_xx_0, '0']

metadata:
  file_format: 1
